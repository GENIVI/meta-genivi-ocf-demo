require recipes-dev-platform/images/genivi-dev-platform.bb

IMAGE_INSTALL += " iotivity "
IMAGE_INSTALL += " iotivitymap "
